COMPATIBLE_MACHINE:append = "|lea-trevally"
