FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://index.html.lighttpd \
    file://lighttpd.conf \
"
