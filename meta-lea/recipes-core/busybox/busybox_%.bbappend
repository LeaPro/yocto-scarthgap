SRC_URI += "file://fragment.cfg;subdir=busybox-1.33.0"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

